# Keil uVision project FreeRTOS.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CONFIG\FreeRTOS;..\CONFIG\FreeRTOS\include;..\CONFIG\FreeRTOS\portable\RVDS\ARM_CM4F;..\CONFIG\CORE;..\CONFIG\SYSTEM\delay;..\CONFIG\SYSTEM\sys;..\CONFIG\FWLIB\inc;..\MDK;..\CONFIG\MODEULE;..\CONFIG\TASK;..\CONFIG\SYSTEM\usart;..\CONFIG\BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c main.c stm32f4xx_it.c defines.h include.h
  group CORE
    ../CONFIG/CORE/: startup_stm32f40_41xxx.s
  group SYSTERM
    ../CONFIG/SYSTEM/delay/: delay.c
    ../CONFIG/SYSTEM/sys/: sys.c
    ../CONFIG/SYSTEM/usart/: usart.c
  group FWLIB
    ../CONFIG/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dbgmcu.c stm32f4xx_dac.c stm32f4xx_can.c stm32f4xx_syscfg.c
  group FreeRTOS
    ../CONFIG/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../CONFIG/FreeRTOS/portable/MemMang/: heap_4.c
    ../CONFIG/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../CONFIG/BSP/: bsp_adc.c bsp_adc.h bsp_ADS1115.c bsp_ADS1115.h bsp_air.c bsp_air.h bsp_oled.c bsp_oled.h bsp_pid.c bsp_pid.h font.h OLED_I2C.h picture.h bsp_key.c bsp_key.h
  group MODULE
    ../CONFIG/MODEULE/: md_s_curve.c
  group TASK
    ../CONFIG/TASK/: tk_fsm.c tk_fsm.h tk_Information.c tk_Information.h tk_show.c tk_show.h
